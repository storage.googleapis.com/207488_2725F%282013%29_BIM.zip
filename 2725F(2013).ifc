Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-09-13T15:35:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 13 15:35:04 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{033E908A-78F3-4EC0-96C4-A7681E156A8F}\ifc * Database version: 5507 * Database creation date: Thu Sep 13 15:35:03 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 13 15:35:03 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 13 15:35:03 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 2725F Kitchen faucet with dishwasher valve, 3 V, 2725F:2725F Kitchen faucet with dishwasher valve, 3 V:331583
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 255.5 mm; NominalHeight: 294 mm; NominalWidth: 122 mm
Type - Electrical(Type) - Battery: AA 1.5 V Lithium x 2; Operating Voltage: 3 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 2725F; ConvergoRefNr: 0087-1806-0036-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Kitchen faucet with an easy-grip lever, high swivel spout and aerator.; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 12/09/2018
Type - Green Building Properties(Type) - EAN Number: 6414150070044; EMC Directive: 2004/108/EY; EN Standard: EN 817; LVI Number: 6219074; Noise Class: I (ISO 3822); NRF Number: 4200376; Protection Class: IP 54; RSK Number: 8553479; Sintef Certificate: Sintef Nr. 3083; STF Certificate: VTT-RTH-00008-14; VVS Number: 705683504
Type - Identity Data(Type) - Class: Hybrid, two handle, touchless, battery operated; Group: Kitchen faucets; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;NOR;POL;RUS;SWE;UKR; Model: 2725F Kitchen faucet with dishwasher valve, 3 V; Name_en: 2725F Kitchen faucet with dishwasher valve, 3 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2725F; Product Datasheet: https://www.oras.com/datasheet/2725F/en; Product Family: Oras Optima; Product URL: https://www.oras.com/en/products/oras-optima/product/2725F/; Type Name: 2725F Kitchen faucet with dishwasher valve, 3 V; Usage Group: Offices;Households
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Aerator: Aerator; Dishwasher Valve: SmartDWV; Dishwasher Valve Open Period: 4 h / 12 h; Flow period: 4 s; Flow Rate At 300kPa: 0.00706293 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/117177_943131-09-15.pdf; Installation Type: Deck mounted; Lever Handle: Easy grip lever; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 40; Mechanical Parts: Litter filter; Mounting Holes: 1 mounting hole; Pipes: Flexible inlet pipes; Pressure Loss With Flow 02ls: 290000 Pa; Recognition Range: optimally preset; Spare Parts: https://www.oras.com/en/products/oras-optima/spareparts/SP2725F/; Spout Type: Swivel spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Kitchen; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2725F; Features: Hybrid, two handle, touchless, battery operated; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2725F; Name: 2725F Kitchen faucet with dishwasher valve, 3 V; ReplacementCost: n/a; Shape: Sculptured; Size: 120x255x300 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2725F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2725F Kitchen faucet with dishwasher valve, 3 V
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.143067 m2; Volume: 0.0091534 m3
Identity Data - Mark: 10
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 2725F: 2725F Kitchen faucet with dishwasher valve, 3 V; Family and Type: 2725F: 2725F Kitchen faucet with dishwasher valve, 3 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2725F: 2725F Kitchen faucet with dishwasher valve, 3 V; Type Id: 2725F: 2725F Kitchen faucet with dishwasher valve, 3 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
